# Keil uVision project ot_nrf52833_libnordicsemi_nrf52833_radio_driver_softdevice.uvprojx, settings and files
target libnordicsemi_nrf52833_radio_driver_softdevice (ARM-ADS)
  device: nRF52833_xxAA Nordic Semiconductor
  pack: ..
  output: libnordicsemi-nrf52833-radio-driver-softdevice (library)
  c flags: Optim=s OneElfS=1 uC99=1
  c define: CONFIG_GPIO_AS_PINRESET DISABLE_CC310=1 ENABLE_FEM=1 FLOAT_ABI_HARD HAVE_CONFIG_H MBEDTLS_CONFIG_FILE=\"mbedtls-config.h\" MBEDTLS_USER_CONFIG_FILE=\"nrf52833-mbedtls-config.h\" NRF52833_XXAA NRF_802154_PROJECT_CONFIG=\"platform-config.h\" OPENTHREAD_CONFIG_BORDER_AGENT_ENABLE=1 OPENTHREAD_CONFIG_BORDER_ROUTER_ENABLE=1 OPENTHREAD_CONFIG_CHILD_SUPERVISION_ENABLE=1 OPENTHREAD_CONFIG_COAP_API_ENABLE=1 OPENTHREAD_CONFIG_COAP_SECURE_API_ENABLE=1 OPENTHREAD_CONFIG_COMMISSIONER_ENABLE=1 OPENTHREAD_CONFIG_DHCP6_CLIENT_ENABLE=1 OPENTHREAD_CONFIG_DHCP6_SERVER_ENABLE=1 OPENTHREAD_CONFIG_DIAG_ENABLE=1 OPENTHREAD_CONFIG_DNS_CLIENT_ENABLE=1 OPENTHREAD_CONFIG_ECDSA_ENABLE=1 OPENTHREAD_CONFIG_ENABLE_BUILTIN_MBEDTLS=1 OPENTHREAD_CONFIG_HEAP_EXTERNAL_ENABLE=1 OPENTHREAD_CONFIG_IP6_SLAAC_ENABLE=1 OPENTHREAD_CONFIG_JAM_DETECTION_ENABLE=1 OPENTHREAD_CONFIG_JOINER_ENABLE=1 OPENTHREAD_CONFIG_LINK_RAW_ENABLE=1 OPENTHREAD_CONFIG_MAC_FILTER_ENABLE=1 OPENTHREAD_CONFIG_NCP_UART_ENABLE=1 OPENTHREAD_CONFIG_SNTP_CLIENT_ENABLE=1 OPENTHREAD_CONFIG_THREAD_VERSION=2 OPENTHREAD_CONFIG_TMF_NETDATA_SERVICE_ENABLE=1 OPENTHREAD_CONFIG_TMF_NETWORK_DIAG_MTD_ENABLE=1 OPENTHREAD_CONFIG_UDP_FORWARD_ENABLE=1 OPENTHREAD_CORE_CONFIG_PLATFORM_CHECK_FILE=\"openthread-core-nrf52833-config-check.h\" OPENTHREAD_ENABLE_NCP_SPINEL_ENCRYPTER=0 OPENTHREAD_ENABLE_VENDOR_EXTENSION=0 OPENTHREAD_EXAMPLES_SIMULATION=0 OPENTHREAD_PLATFORM_POSIX=0 OPENTHREAD_POSIX_CONFIG_DAEMON_ENABLE=0 OPENTHREAD_PROJECT_CORE_CONFIG_FILE=\"openthread-core-nrf52833-config.h\" RAAL_SOFTDEVICE=1 S140 SOFTDEVICE_PRESENT UART_AS_SERIAL_TRANSPORT=1 USE_APP_CONFIG=1 __HEAP_SIZE=4096 __STACK_SIZE=4096
  c misc: --reduce_paths
  c include: ..\..\..\config;..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio;..\..\..\..\config;..\..\..;..\..\..\..\openthread\examples\platforms\nrf52833;..\..\..\..\openthread\examples\platforms\nrf528xx\nrf52833;..\..\..\..\openthread\include;..\..\..\..\openthread\src\core;..\..\..\..\openthread\third_party\NordicSemiconductor;..\..\..\..\openthread\third_party\NordicSemiconductor\cmsis;..\..\..\..\openthread\third_party\NordicSemiconductor\config;..\..\..\..\openthread\third_party\NordicSemiconductor\config\nrf52833\config;..\..\..\..\openthread\third_party\NordicSemiconductor\dependencies;..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\clock;..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\common;..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\power;..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\fem;..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\fem\three_pin_gpio;..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\mac_features;..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\mac_features\ack_generator;..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\rsch;..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\rsch\raal;..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\rsch\raal\softdevice;..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\systick;..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\usbd;..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\app_error;..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\atfifo;..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\atomic;..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\block_dev;..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\delay;..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\nrf_security\mbedtls_plat_config;..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\usb;..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\usb\class\cdc;..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\usb\class\cdc\acm;..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\usb\config;..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\utf_converter;..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx;..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\drivers;..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\drivers\include;..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\hal;..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\mdk;..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\soc;..\..\..\..\openthread\third_party\NordicSemiconductor\softdevice\s140\headers;..\..\..\..\openthread\third_party\NordicSemiconductor\softdevice\s140\headers\nrf52;..\..\..\..\openthread\third_party\mbedtls\repo\include;..\..\..\..\openthread\third_party\mbedtls\repo\include\mbedtls
  asm define: as above
  asm misc: --cpreproc_opts=-DCONFIG_GPIO_AS_PINRESET,-DDISABLE_CC310=1,-DENABLE_FEM=1,-DFLOAT_ABI_HARD,-DHAVE_CONFIG_H,-DMBEDTLS_CONFIG_FILE=\"mbedtls-config.h\",-DMBEDTLS_USER_CONFIG_FILE=\"nrf52833-mbedtls-config.h\",-DNRF52833_XXAA,-DNRF_802154_PROJECT_CONFIG=\"platform-config.h\",-DOPENTHREAD_CONFIG_BORDER_AGENT_ENABLE=1,-DOPENTHREAD_CONFIG_BORDER_ROUTER_ENABLE=1,-DOPENTHREAD_CONFIG_CHILD_SUPERVISION_ENABLE=1,-DOPENTHREAD_CONFIG_COAP_API_ENABLE=1,-DOPENTHREAD_CONFIG_COAP_SECURE_API_ENABLE=1,-DOPENTHREAD_CONFIG_COMMISSIONER_ENABLE=1,-DOPENTHREAD_CONFIG_DHCP6_CLIENT_ENABLE=1,-DOPENTHREAD_CONFIG_DHCP6_SERVER_ENABLE=1,-DOPENTHREAD_CONFIG_DIAG_ENABLE=1,-DOPENTHREAD_CONFIG_DNS_CLIENT_ENABLE=1,-DOPENTHREAD_CONFIG_ECDSA_ENABLE=1,-DOPENTHREAD_CONFIG_ENABLE_BUILTIN_MBEDTLS=1,-DOPENTHREAD_CONFIG_HEAP_EXTERNAL_ENABLE=1,-DOPENTHREAD_CONFIG_IP6_SLAAC_ENABLE=1,-DOPENTHREAD_CONFIG_JAM_DETECTION_ENABLE=1,-DOPENTHREAD_CONFIG_JOINER_ENABLE=1,-DOPENTHREAD_CONFIG_LINK_RAW_ENABLE=1,-DOPENTHREAD_CONFIG_MAC_FILTER_ENABLE=1,-DOPENTHREAD_CONFIG_NCP_UART_ENABLE=1,-DOPENTHREAD_CONFIG_SNTP_CLIENT_ENABLE=1,-DOPENTHREAD_CONFIG_THREAD_VERSION=2,-DOPENTHREAD_CONFIG_TMF_NETDATA_SERVICE_ENABLE=1,-DOPENTHREAD_CONFIG_TMF_NETWORK_DIAG_MTD_ENABLE=1,-DOPENTHREAD_CONFIG_UDP_FORWARD_ENABLE=1,-DOPENTHREAD_CORE_CONFIG_PLATFORM_CHECK_FILE=\"openthread-core-nrf52833-config-check.h\",-DOPENTHREAD_ENABLE_NCP_SPINEL_ENCRYPTER=0,-DOPENTHREAD_ENABLE_VENDOR_EXTENSION=0,-DOPENTHREAD_EXAMPLES_SIMULATION=0,-DOPENTHREAD_PLATFORM_POSIX=0,-DOPENTHREAD_POSIX_CONFIG_DAEMON_ENABLE=0,-DOPENTHREAD_PROJECT_CORE_CONFIG_FILE=\"openthread-core-nrf52833-config.h\",-DRAAL_SOFTDEVICE=1,-DS140,-DSOFTDEVICE_PRESENT,-DUART_AS_SERIAL_TRANSPORT=1,-DUSE_APP_CONFIG=1,-D__HEAP_SIZE=4096,-D__STACK_SIZE=4096
  asm include: as above
  library: MicroLIB
  link misc: --diag_suppress 6330
  group openthread
    ../../../../openthread/third_party/NordicSemiconductor/drivers/radio/: nrf_802154.c nrf_802154_core.c nrf_802154_core_hooks.c nrf_802154_critical_section.c nrf_802154_debug.c nrf_802154_notification_swi.c nrf_802154_pib.c nrf_802154_priority_drop_swi.c nrf_802154_request_swi.c nrf_802154_rssi.c nrf_802154_rx_buffer.c nrf_802154_swi.c nrf_802154_timer_coord.c
    ../../../../openthread/third_party/NordicSemiconductor/drivers/radio/mac_features/ack_generator/: nrf_802154_ack_data.c nrf_802154_ack_generator.c nrf_802154_enh_ack_generator.c nrf_802154_imm_ack_generator.c
    ../../../../openthread/third_party/NordicSemiconductor/drivers/radio/platform/clock/: nrf_802154_clock_ot.c
    ../../../../openthread/third_party/NordicSemiconductor/drivers/radio/mac_features/: nrf_802154_csma_ca.c nrf_802154_delayed_trx.c nrf_802154_filter.c nrf_802154_frame_parser.c nrf_802154_precise_ack_timeout.c
    ../../../../openthread/third_party/NordicSemiconductor/drivers/radio/fal/: nrf_802154_fal.c
    ../../../../openthread/third_party/NordicSemiconductor/drivers/radio/platform/hp_timer/: nrf_802154_hp_timer.c
    ../../../../openthread/third_party/NordicSemiconductor/drivers/radio/rsch/: nrf_802154_rsch.c nrf_802154_rsch_crit_sect.c
    ../../../../openthread/third_party/NordicSemiconductor/drivers/radio/timer_scheduler/: nrf_802154_timer_sched.c
    ../../../../openthread/third_party/NordicSemiconductor/drivers/radio/platform/coex/: nrf_802154_wifi_coex_none.c
    ../../../../openthread/third_party/NordicSemiconductor/drivers/radio/fem/three_pin_gpio/: nrf_fem_three_pin_gpio.c
    ../../../../openthread/third_party/NordicSemiconductor/drivers/radio/rsch/raal/softdevice/: nrf_raal_softdevice.c
